## drivers/mstar/pwm/Kconfig
```kconfig
config SSTAR_PWM
	bool "sigauth"
	help
	  This enables the command sigauth which only authenticate image
	  with signature.
```
